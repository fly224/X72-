# Keil uVision project X72_FOC.uvprojx, settings and files
target X72_FOC (6240000::V6.24::ARMCLANG)
  device: STM32G474CEUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: X72_FOC +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32G474xx,ARM_MATH_CM4
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../../../app;../../../app/Identify;../../../motor_control;../../../communication/protocol;../../../communication/callback;../../../board_public/flash_db;../../../board_public/system_manage;../../../simulink_code_gen
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: stm32g474xx_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c fdcan.c opamp.c spi.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_opamp.c stm32g4xx_hal_opamp_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Application/User/Servo
    ../../../board_public/system_manage/: bsp_servo.c
    ../../../motor_control/: servo_isr.c motion_profile.c pos_loop.c vel_profile.c servo_cmd.c deadband_comp.c cog_ff.c enc_comp.c
    ../../../simulink_code_gen/: three_loop_deploy.c
    ../../../communication/callback/: telemetry_tx.c
    ../../../communication/protocol/: uart_link.c can_proto.c canopen.c canopen.h mavlink_common.c mavlink_host.c
    ../../../app/Identify/: motor_ident.c cur_step.c motor_rl_ident.c encoder_cal.c actuator.c fric_cal.c mech_ident.c motor_flux_ident.c
    ../../../board_public/flash_db/: param_store.c
    ../../../app/: app_param.c
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.14.2
